# Keil uVision project LCXKP_FLASH_SPI.uvprojx, settings and files
target LCXKP_FLASH_SPI (5060960::V5.06 update 7 (build 960)::.\ARMCLANG_V5.06U7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LCXKP_FLASH_SPI +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Drivers/CMSIS/Include;..\Drivers\FLASH;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\target.lin
  link misc: --diag_suppress L6305
  group Drivers/FLASH
    ../Drivers/FLASH/: FlashDev.c FlashPrg.c
software components: CMSIS:CORE 4.3.0
